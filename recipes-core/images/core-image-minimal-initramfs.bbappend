# Copyright (C) 2026 Savoir-faire Linux, Inc.
# SPDX-License-Identifier: Apache-2.0

DEPENDS += "kconfig-hardened-check-native"
