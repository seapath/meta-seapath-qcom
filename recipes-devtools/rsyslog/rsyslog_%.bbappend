# Copyright (C) 2026 Savoir-faire Linux, Inc.
# SPDX-License-Identifier: Apache-2.0

SRC_URI:remove = "file://rsyslog.conf.qcom"
SRC_URI:append:qcom = " file://rsyslog.conf.qcom"
